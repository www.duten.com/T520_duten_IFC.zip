Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: f2ae0c5c-f3bd-4641-91d4-e4f4520248e2, NumberOfSaves: 69], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: Project Number
Time: 2024-07-05T15:18:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.6.2.0 - Alternate UI 22.6.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 05 15:18:02 2024 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\771be0ad-a090-408d-9bac-76592f37ad6d\7e8637b3-3d0f-44aa-91aa-90fcc00799ea\ifc * Database version: 5507 * Database creation date: Fri Jul 05 15:18:01 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 05 15:18:02 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 05 15:18:02 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding, n/a
LongName: n/a
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
In: n/a
Pset_ProductRequirements - Category: Levels
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name | Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcFurnishingElement: DBLTD_Duten_PaperTowelDispensers_T520:Bright Stainless Steel Combination Unit, DBLTD_Duten_PaperTowelDispensers_T520:Bright Stainless Steel Combination Unit:463863
In: Level 0
Type - Material: DBLTD_Duten_Metal_PolishedStainlessSteel
Type - Pset_FurnitureTypeCommon - Description: Bright Stainless Steel Combination Unit; NominalHeight: 1362 mm; NominalLength: 120 mm
Type - Pset_ElementShading - Color: Available in Brushed Stainless Steel, Bright Stainless Steel, Brushed Brass or Matte Black
Type - Pset_ManufacturerTypeInformation - ModelReference: Bright Stainless Steel Combination Unit; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Combination Paper Towel and Bin Unit; Category: Generic Models
Classification: E2020200 Uniformat (Uniformat)
Pset_QuantityTakeOff - Reference: Bright Stainless Steel Combination Unit

# IfcFurnishingElement: DBLTD_Duten_PaperTowelDispensers_T520:Brushed Brass Combination Unit, DBLTD_Duten_PaperTowelDispensers_T520:Brushed Brass Combination Unit:463952
In: Level 0
Type - Material: DBLTD_Duten_Metal_BrushedBrass
Type - Pset_FurnitureTypeCommon - Description: Brushed Brass Combination Unit; NominalHeight: 1362 mm; NominalLength: 120 mm
Type - Pset_ElementShading - Color: Available in Brushed Stainless Steel, Bright Stainless Steel, Brushed Brass or Matte Black
Type - Pset_ManufacturerTypeInformation - ModelReference: Brushed Brass Combination Unit; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Combination Paper Towel and Bin Unit; Category: Generic Models
Classification: E2020200 Uniformat (Uniformat)
Pset_QuantityTakeOff - Reference: Brushed Brass Combination Unit

# IfcFurnishingElement: DBLTD_Duten_PaperTowelDispensers_T520:Brushed Stainless Steel Combination Unit, DBLTD_Duten_PaperTowelDispensers_T520:Brushed Stainless Steel Combination Unit:463975
In: Level 0
Type - Material: DBLTD_Duten_Metal_BrushedStainlessSteel
Type - Pset_FurnitureTypeCommon - Description: Brushed Stainless Steel Combination Unit; NominalHeight: 1362 mm; NominalLength: 120 mm
Type - Pset_ElementShading - Color: Available in Brushed Stainless Steel, Bright Stainless Steel, Brushed Brass or Matte Black
Type - Pset_ManufacturerTypeInformation - ModelReference: Brushed Stainless Steel Combination Unit; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Combination Paper Towel and Bin Unit; Category: Generic Models
Classification: E2020200 Uniformat (Uniformat)
Pset_QuantityTakeOff - Reference: Brushed Stainless Steel Combination Unit

# IfcFurnishingElement: DBLTD_Duten_PaperTowelDispensers_T520:Matt Black Combination Unit, DBLTD_Duten_PaperTowelDispensers_T520:Matt Black Combination Unit:464021
In: Level 0
Type - Material: DBLTD_Duten_Metal_MatteBlack
Type - Pset_FurnitureTypeCommon - Description: Matt Black Combination Unit; NominalHeight: 1362 mm; NominalLength: 120 mm
Type - Pset_ElementShading - Color: Available in Brushed Stainless Steel, Bright Stainless Steel, Brushed Brass or Matte Black
Type - Pset_ManufacturerTypeInformation - ModelReference: Matt Black Combination Unit; Manufacturer: Duten
Type - Pset_ProductRequirements - Name: Combination Paper Towel and Bin Unit; Category: Generic Models
Classification: E2020200 Uniformat (Uniformat)
Pset_QuantityTakeOff - Reference: Matt Black Combination Unit
